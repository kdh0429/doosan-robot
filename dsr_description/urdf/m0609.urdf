Commit message: Create a node that reproduces the experiment

File: dsr_description/urdf/m0609.urdf (robot description, URDF)
Before this commit: robot m0609, 8 links, 7 joints
Links:
- removed link base
Joints:
- removed joint fixed
